# Keil uVision project WF_AO_Module.uvprojx, settings and files
target LPC1768 Flash (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: LPC1759 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: WF_MOD_18b +hex
  AfterMake: Flash\fromelf_post.bat "$L@L.axf"
  AfterMake: .\Flash\Binary_Encrypt_LPC1768.exe
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\1_Menu_Struct;.\Generic;.\Generic\abcc_abp;.\Generic\abcc_adapt;.\Generic\abcc_drv\inc;.\Generic\abcc_drv\src\par;.\Generic\abcc_drv\src\par30;.\Generic\abcc_drv\src\serial;.\Generic\abcc_drv\src\spi;.\Generic\abcc_drv\src;.\Generic\abcc_drv;.\Generic\abcc_obj\nw_obj;.\Generic\abcc_obj;.\Generic\example_app;..\AAG_WF_V1.H.1_18.03.2023_ModifiedByPG;.\cmsis_drvr\Drivers\include
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x60000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group SFF_Source Files
    ./: lpc17xx_gpio.c OLED_2_7_12864.c Font_Arial_16.c Font_Arial_32.c Font_Calibri_10.c menu.c Joystick_MCB1700.c GPIO_LPC17xx.c keys.c lpc17xx_rtc.c lpc17xx_clkpwr.c rtc.c lpc17xx_timer.c Timer.c lpc17xx_nvic.c adc.c eeprom.c lpc17xx_spi.c lpc17xx_uart.c print_uart.c spi_test.c calibration.c filter.c Online.c key_control.c plc.c io_control.c initialize.c totalizer.c modbus.c main.c Error_list.c Dac.c adc_12bit.c Integrate.c Tacho.c Zeroing_Process.c Online_menus.c Modbus_Registers.c Digital_Input_Actions.c load_cell_flter_claculations.c Modbus_DIO.c RAM512KB_Ext.c Ram_adress_data_display.c Inverter.c lpc17xx_pinsel.c usb_app.c Valve_Control.c Auto Calibration.c Controls.c
  group Documentation
    ./: Abstract.txt
    ./Inverter Configuration parameter list/: Inverters Configuration Parameters List_11102019.txt
  group abc_abp
    ./Generic/abcc_abp/: abp.h abp_add.h abp_asm.h abp_bac.h abp_ccl.h abp_cfn.h abp_cipid.h abp_cnt.h abp_cop.h abp_cpc.h abp_cpn.h abp_dev.h abp_dpv0di.h abp_dpv1.h abp_eco.h abp_ect.h abp_eip.h abp_eme.h abp_epl.h abp_er.h abp_etn.h abp_fsi.h abp_fusm.h abp_mdd.h abp_mod.h abp_nwccl.h abp_nwcfn.h abp_nwdpv1.h abp_nwetn.h abp_nwpnio.h abp_opcua.h abp_pnam.h abp_pnio.h abp_safe.h abp_smtp.h abp_soc.h abp_src3.h abp_sync.h
  group abcc_adapt
    ./Generic/abcc_adapt/: abcc_drv_cfg.h abcc_identification.h abcc_obj_cfg.h abcc_platform_cfg.h abcc_sw_port.c abcc_sw_port.h abcc_sys_adapt.c abcc_td.h
  group abcc_drv
    ./Generic/abcc_drv/inc/: abcc.h abcc_ad_if.h abcc_cfg.h abcc_cmd_seq_if.h abcc_port.h abcc_sys_adapt.h abcc_sys_adapt_par.h abcc_sys_adapt_ser.h abcc_sys_adapt_spi.h
    ./Generic/abcc_drv/src/par/: abcc_drv_par_if.h abcc_handler_par.c abcc_par_drv.c
    ./Generic/abcc_drv/src/par30/: abcc_drv_par30_if.h abcc_handler_par30.c abcc_par30_drv.c
    ./Generic/abcc_drv/src/serial/: abcc_crc16.c abcc_crc16.h abcc_drv_ser_if.h abcc_handler_ser.c abcc_serial_drv.c
    ./Generic/abcc_drv/src/spi/: abcc_crc32.c abcc_crc32.h abcc_drv_spi_if.h abcc_handler_spi.c abcc_spi_drv.c
    ./Generic/abcc_drv/src/: abcc_cmd_seq.c abcc_cmd_seq.h abcc_debug_err.c abcc_debug_err.h abcc_drv_if.h abcc_handler.c abcc_handler.h abcc_link.c abcc_link.h abcc_mem.c abcc_mem.h abcc_remap.c abcc_setup.c abcc_setup.h abcc_timer.c abcc_timer.h
  group abcc_obj
    ./Generic/abcc_obj/nw_obj/: ccl.c ccl.h cfn.c cfn.h cop.c cop.h dev.c dev.h dpv1.c dpv1.h ect.c ect.h eip.c eip.h epl.c epl.h mod.c mod.h prt.c prt.h
    ./Generic/abcc_obj/: ad_obj.c ad_obj.h app_obj.c app_obj.h etn_obj.c etn_obj.h opcua_obj.c opcua_obj.h safe_obj.c safe_obj.h sync_obj.c sync_obj.h
  group example_app
    ./Generic/example_app/: appl_abcc_handler.c appl_abcc_handler.h appl_adi_config.h appl_adimap_alltypes.c appl_adimap_separate16.c appl_adimap_simple16.c appl_adimap_speed_example.c appl_adimap_sync.c appl_adimap_verif.c modbus.h plc.h
    ./: parameters.h
  group ABCC_Main
    ./Generic/: abcc_versions.h ABCC40_main.c
software components: CMSIS:CORE 5.0.2, CMSIS:RTOS:Keil RTX 4.81.1, Board Support:MCB1700:LED 1.0.0, CMSIS Driver:USART 2.13.0, Device:GPDMA 1.4.0, Device:PIN 1.0.0, Device:Startup 1.0.0
